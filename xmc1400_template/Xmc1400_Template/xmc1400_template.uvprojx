# Keil uVision project xmc1400_template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1404-Q064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.11.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: xmc1400_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XMC1404_Q064x0200
  c include: ..\Startup\RTE\KIT_XMC14_BOOT_001;..\Xmc1400_Template;..\LowLevelDrivers\XMC1400\CMSIS\Include;..\LowLevelDrivers\XMC1400\CMSIS\Infineon\XMC1400_series\Include;..\LowLevelDrivers\XMC1400\XMCLib\inc
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Group 1
    ./: main.c uart_app.c uart_app.h can.c
    ../Startup/RTE/Device/XMC1404-Q064x0200/: startup_XMC1400.s system_XMC1400.c
  group New Group
    ../LowLevelDrivers/XMC1400/XMCLib/src/: xmc_acmp.c xmc_bccu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_eru.c xmc_gpio.c xmc_i2c.c xmc_i2s.c xmc_ledts.c xmc_math.c xmc_pau.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c
